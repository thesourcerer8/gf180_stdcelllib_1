*** Spice netlist generated by cell2spice.pl from cell file AAOI22.cell ***

.subckt AAOI22 VDD GND B1 B A1 A Y
M0 N1 B1 VDD VDD pmos w=1.32u l=0.6u
M1 N1 B VDD VDD pmos w=1.32u l=0.6u
M2 Y A1 N1 VDD pmos w=1.32u l=0.6u
M3 Y A N1 VDD pmos w=1.32u l=0.6u
M4 N2 B1 GND GND nmos w=1.83u l=0.5u
M5 N1 B N2 GND nmos w=1.83u l=0.5u
M6 N A1 GND GND nmos w=1.83u l=0.5u
M7 Y A N GND nmos w=1.83u l=0.5u
.ends AAOI22
