*** Spice netlist generated by cell2spice.pl from cell file AAAAOI3322.cell ***

.subckt AAAAOI3322 VDD GND D1 D C1 C B2 B1 B A2 A1 A Y
M0 N7 D1 VDD VDD pmos w=1.32u l=0.6u
M1 N7 D VDD VDD pmos w=1.32u l=0.6u
M2 N5 C1 N7 VDD pmos w=1.32u l=0.6u
M3 N5 C N7 VDD pmos w=1.32u l=0.6u
M4 N2 B2 N5 VDD pmos w=1.32u l=0.6u
M5 N2 B1 N5 VDD pmos w=1.32u l=0.6u
M6 N2 B N5 VDD pmos w=1.32u l=0.6u
M7 Y A2 N2 VDD pmos w=1.32u l=0.6u
M8 Y A1 N2 VDD pmos w=1.32u l=0.6u
M9 Y A N2 VDD pmos w=1.32u l=0.6u
M10 N8 D1 GND GND nmos w=1.83u l=0.5u
M11 N7 D N8 GND nmos w=1.83u l=0.5u
M12 N6 C1 GND GND nmos w=1.83u l=0.5u
M13 N5 C N6 GND nmos w=1.83u l=0.5u
M14 N4 B2 GND GND nmos w=1.83u l=0.5u
M15 N3 B1 N4 GND nmos w=1.83u l=0.5u
M16 N2 B N3 GND nmos w=1.83u l=0.5u
M17 N1 A2 GND GND nmos w=1.83u l=0.5u
M18 N A1 N1 GND nmos w=1.83u l=0.5u
M19 Y A N GND nmos w=1.83u l=0.5u
.ends AAAAOI3322
