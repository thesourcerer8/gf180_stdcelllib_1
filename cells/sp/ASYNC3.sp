*** Spice netlist generated by cell2spice.pl from cell file ASYNC3.cell ***

.subckt ASYNC3 VDD GND A B C CN
M0 CN B NET2 GND nmos w=1.83u l=0.5u
M1 NET2 A GND GND nmos w=1.83u l=0.5u
M2 CN A NET1 GND nmos w=1.83u l=0.5u
M3 C CN GND GND nmos w=1.83u l=0.5u
M4 NET1 B GND GND nmos w=1.83u l=0.5u
M5 NET2 C NET1 GND nmos w=1.83u l=0.5u
M6 CN B NET3 VDD pmos w=1.32u l=0.6u
M7 NET3 A VDD VDD pmos w=1.32u l=0.6u
M8 NET4 B VDD VDD pmos w=1.32u l=0.6u
M9 CN A NET4 VDD pmos w=1.32u l=0.6u
M10 C CN VDD VDD pmos w=1.32u l=0.6u
M11 NET4 C NET3 VDD pmos w=1.32u l=0.6u
.ends ASYNC3
