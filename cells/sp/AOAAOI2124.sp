*** Spice netlist generated by cell2spice.pl from cell file AOAAOI2124.cell ***

.subckt AOAAOI2124 VDD GND D3 D2 D1 D C1 C B A1 A Y
M0 N4 D3 VDD VDD pmos w=1.32u l=0.6u
M1 N4 D2 VDD VDD pmos w=1.32u l=0.6u
M2 N4 D1 VDD VDD pmos w=1.32u l=0.6u
M3 N4 D VDD VDD pmos w=1.32u l=0.6u
M4 N2 C1 N4 VDD pmos w=1.32u l=0.6u
M5 N2 C N4 VDD pmos w=1.32u l=0.6u
M6 N1 B N4 VDD pmos w=1.32u l=0.6u
M7 Y A1 N1 VDD pmos w=1.32u l=0.6u
M8 Y A N1 VDD pmos w=1.32u l=0.6u
M9 N7 D3 GND GND nmos w=1.83u l=0.5u
M10 N6 D2 N7 GND nmos w=1.83u l=0.5u
M11 N5 D1 N6 GND nmos w=1.83u l=0.5u
M12 N4 D N5 GND nmos w=1.83u l=0.5u
M13 N3 C1 GND GND nmos w=1.83u l=0.5u
M14 N2 C N3 GND nmos w=1.83u l=0.5u
M15 N1 B N2 GND nmos w=1.83u l=0.5u
M16 N A1 N2 GND nmos w=1.83u l=0.5u
M17 Y A N GND nmos w=1.83u l=0.5u
.ends AOAAOI2124
