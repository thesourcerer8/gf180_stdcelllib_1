*** Spice netlist generated by cell2spice.pl from cell file MUX8.cell ***

.subckt MUX8 VDD GND IN0 IN1 IN2 IN3 IN4 IN5 IN6 IN7 S0 S1 S2 S3 S4 S5 S6 S7 Z
M0 INT0 IN0 VDD VDD pmos w=1.32u l=0.6u
M1 INT0 IN0 GND GND nmos w=1.83u l=0.5u
M2 INT0 S0 Y VDD pmos w=1.32u l=0.6u
M3 INT0 S0 Y GND nmos w=1.83u l=0.5u
M4 INT1 IN1 VDD VDD pmos w=1.32u l=0.6u
M5 INT1 IN1 GND GND nmos w=1.83u l=0.5u
M6 INT1 S1 Y VDD pmos w=1.32u l=0.6u
M7 INT1 S1 Y GND nmos w=1.83u l=0.5u
M8 INT2 IN2 VDD VDD pmos w=1.32u l=0.6u
M9 INT2 IN2 GND GND nmos w=1.83u l=0.5u
M10 INT2 S2 Y VDD pmos w=1.32u l=0.6u
M11 INT2 S2 Y GND nmos w=1.83u l=0.5u
M12 INT3 IN3 VDD VDD pmos w=1.32u l=0.6u
M13 INT3 IN3 GND GND nmos w=1.83u l=0.5u
M14 INT3 S3 Y VDD pmos w=1.32u l=0.6u
M15 INT3 S3 Y GND nmos w=1.83u l=0.5u
M16 INT4 IN4 VDD VDD pmos w=1.32u l=0.6u
M17 INT4 IN4 GND GND nmos w=1.83u l=0.5u
M18 INT4 S4 Y VDD pmos w=1.32u l=0.6u
M19 INT4 S4 Y GND nmos w=1.83u l=0.5u
M20 INT5 IN5 VDD VDD pmos w=1.32u l=0.6u
M21 INT5 IN5 GND GND nmos w=1.83u l=0.5u
M22 INT5 S5 Y VDD pmos w=1.32u l=0.6u
M23 INT5 S5 Y GND nmos w=1.83u l=0.5u
M24 INT6 IN6 VDD VDD pmos w=1.32u l=0.6u
M25 INT6 IN6 GND GND nmos w=1.83u l=0.5u
M26 INT6 S6 Y VDD pmos w=1.32u l=0.6u
M27 INT6 S6 Y GND nmos w=1.83u l=0.5u
M28 INT7 IN7 VDD VDD pmos w=1.32u l=0.6u
M29 INT7 IN7 GND GND nmos w=1.83u l=0.5u
M30 INT7 S7 Y VDD pmos w=1.32u l=0.6u
M31 INT7 S7 Y GND nmos w=1.83u l=0.5u
M32 Z Y VDD VDD pmos w=1.32u l=0.6u
M33 Z Y GND GND nmos w=1.83u l=0.5u
.ends MUX8
