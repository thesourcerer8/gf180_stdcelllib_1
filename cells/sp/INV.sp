*** Spice netlist generated by cell2spice.pl from cell file INV.cell ***

.subckt INV VDD GND A Y
M0 Y A VDD VDD pmos w=1.32u l=0.6u
M1 Y A GND GND nmos w=1.83u l=0.5u
.ends INV
